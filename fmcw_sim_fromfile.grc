options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: fmcw_sim
    output_language: python
    title: LFMCW Radar Simulation
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: (max_freq-min_freq)/t_chirp
  states: {}
- name: c
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: delay_samples
  id: variable
  parameters:
    value: int(delay_time*samp_rate)
  states: {}
- name: delay_time
  id: variable
  parameters:
    value: 2*distance_m/c
  states: {}
- name: df
  id: variable
  parameters:
    value: samp_rate/k_bins
  states: {}
- name: distance_m
  id: variable
  parameters:
    value: '100'
  states: {state: disabled}
- name: distance_m
  id: variable_qtgui_range
  parameters:
    label: Object Distance
    start: '0'
    step: '1'
    stop: distance_max_m
    value: '100'
  states: {}
- name: distance_max_m
  id: variable
  parameters:
    value: '200'
  states: {}
- name: distance_per_sample
  id: variable
  parameters:
    value: c/samp_rate
  states: {}
- name: f_b_ideal
  id: variable
  parameters:
    value: 2*distance_m*alpha/c
  states: {}
- name: k_bins
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: max_freq
  id: variable
  parameters:
    value: samp_rate*0.4
  states: {}
- name: min_freq
  id: variable
  parameters:
    value: '-max_freq'
  states: {}
- name: reflection_amplitude
  id: variable
  parameters:
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: t_chirp
  id: variable
  parameters:
    value: '0.00004'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_argmax_xx_1
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: k_bins
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: k_bins
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\workspace\ece448_fmcw\chirps\chirp1.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1*df
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: c/2/alpha
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: reflection_amplitude
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: k_bins
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: k_bins
    forward: 'True'
    nthreads: '2'
    shift: 'False'
    type: complex
    window: window.blackmanharris(k_bins)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Demodulated Signal"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: samp_rate/2
    min: '0'
    name: '"beat frequency"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: distance_max_m
    min: '0'
    name: '"object distance"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: k_bins/2
    min: '0'
    name: '"sample"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: k_bins
    x_axis_label: '"Freq"'
    x_start: '0'
    x_step: 1*df
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"By Sample"'
    vlen: k_bins
    x_axis_label: '"k"'
    x_start: '0'
    x_step: '1'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: beat_data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: beat_data
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_argmax_xx_1, '0', virtual_sink_0_0, '0']
- [blocks_argmax_xx_1, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_argmax_xx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_short_to_float_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
