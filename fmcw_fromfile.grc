options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: fmcw_sim
    output_language: python
    title: LFMCW Radar Simulation
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: (max_freq-min_freq)/t_chirp
  states: {}
- name: c
  id: variable
  parameters:
    value: '300000000'
  states: {}
- name: calibration_delay
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '800'
    value: '0'
  states: {}
- name: df
  id: variable
  parameters:
    value: samp_rate/k_bins
  states: {}
- name: distance_max_m
  id: variable
  parameters:
    value: '100'
  states: {}
- name: distance_per_sample
  id: variable
  parameters:
    value: c/samp_rate/2
  states: {}
- name: k_bins
  id: variable
  parameters:
    value: 2**19
  states: {}
- name: max_buffer
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: max_freq
  id: variable
  parameters:
    value: samp_rate*0.4
  states: {}
- name: min_buffer
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: min_freq
  id: variable
  parameters:
    value: '-max_freq'
  states: {}
- name: radio_center
  id: variable
  parameters:
    value: 1e9
  states: {}
- name: radio_rx_gain
  id: variable
  parameters:
    value: '36'
  states: {}
- name: radio_tx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: t_chirp
  id: variable
  parameters:
    value: '0.00004'
  states: {}
- name: blocks_argmax_xx_1
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: k_bins
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: k_bins
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: calibration_delay
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\workspace\ece448_fmcw\chirps\chirp2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1*df
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: c/2/alpha
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: k_bins
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: k_bins
    forward: 'True'
    nthreads: '2'
    shift: 'False'
    type: complex
    window: window.blackmanharris(k_bins)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Demodulated Signal"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    label1: '"Rx"'
    label2: '''Tx'''
    name: '"TxRx Signal"'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: samp_rate/2
    min: '0'
    name: '"beat frequency"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: distance_max_m
    min: '0'
    name: '"object distance"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: k_bins/2
    min: '0'
    name: '"sample"'
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: radio_center
    gain0: radio_tx_gain
    maxoutbuf: max_buffer
    minoutbuf: min_buffer
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: radio_center
    gain0: radio_rx_gain
    maxoutbuf: max_buffer
    minoutbuf: min_buffer
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: beat_data
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: beat_data
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}

connections:
- [blocks_argmax_xx_1, '0', virtual_sink_0_0, '0']
- [blocks_argmax_xx_1, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_argmax_xx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_short_to_float_0, '0', qtgui_number_sink_0_1_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [virtual_source_0_0, '0', blocks_short_to_float_0, '0']
- [virtual_source_0_1, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
